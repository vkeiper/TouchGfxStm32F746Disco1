# IAR project application.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429NI ST STM32F429NI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: ST; STM32F756xx; USE_FREERTOS_8; USE_OS_SYSTICK; USE_STM32746G_DISCOVERY; USE_BPP=16
  ICCARM.CCIncludePath2: ..\..\gui\include; ..\..\target\include; ..\..\platform\os; ..\..\generated\fonts\include; ..\..\generated\images\include; ..\..\generated\texts\include; ..\..\generated\gui_generated\include; ..\..\touchgfx\framework\include; ..\bsp\include\platform\core\arm\cortex-m\CMSIS; ..\bsp\include\platform\stm32f7xx; ..\bsp\include\platform\stm32f7xx\CMSIS; ..\bsp\include\platform\stm32f7xx\STM32F7xx_HAL_Driver; ..\bsp\include; ..\bsp\include\vendor; ..\bsp\source\vendor\STM32746G-Discovery; ..\os\FreeRTOS8.2.0\Source\include; ..\os\FreeRTOS8.2.0\Source\portable\IAR\ST_CM7
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: USE_FREERTOS_8; USE_OS_SYSTICK
  AARM.AUserIncludes: ..\..\platform\os
  OBJCOPY.OOCOutputFile: application.hex
  ILINK.IlinkOutputFile: application.out
  ILINK.IlinkIcfFile: application.icf
  ILINK.IlinkAdditionalLibs: ..\..\touchgfx\lib\core\cortex_m7\IAR8.x\touchgfx_core.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/generated/fonts
    ../../generated/fonts/src/: ApplicationFontProvider.cpp Font_verdana_20_4bpp.cpp Font_verdana_45_4bpp.cpp Font_verdanab_75_4bpp.cpp Font_verdanaz_30_4bpp.cpp FontGetters.cpp Kerning_verdana_20_4bpp.cpp Kerning_verdana_45_4bpp.cpp Kerning_verdanab_75_4bpp.cpp Kerning_verdanaz_30_4bpp.cpp Table_verdana_20_4bpp.cpp Table_verdana_45_4bpp.cpp Table_verdanab_75_4bpp.cpp Table_verdanaz_30_4bpp.cpp
  group Application/generated/gui_generated/common
    ../../generated/gui_generated/src/common/: FrontendApplicationBase.cpp
  group Application/generated/gui_generated/containers
    ../../generated/gui_generated/src/containers/: AtdiBackground_BtnsBase.cpp
  group Application/generated/gui_generated/main_screen
    ../../generated/gui_generated/src/main_screen/: MainViewBase.cpp
  group Application/generated/gui_generated/screencanbus_screen
    ../../generated/gui_generated/src/screencanbus_screen/: screenCanbusViewBase.cpp
  group Application/generated/gui_generated/screenindustrialcontroller_screen
    ../../generated/gui_generated/src/screenindustrialcontroller_screen/: screenIndustrialControllerViewBase.cpp
  group Application/generated/gui_generated/screenmenu_screen
    ../../generated/gui_generated/src/screenmenu_screen/: screenMenuViewBase.cpp
  group Application/generated/gui_generated/screenmodbus_screen
    ../../generated/gui_generated/src/screenmodbus_screen/: screenModbusViewBase.cpp
  group Application/generated/gui_generated/screenzone_screen
    ../../generated/gui_generated/src/screenzone_screen/: screenZoneViewBase.cpp
  group Application/generated/gui_generated/settempcontrol_screen
    ../../generated/gui_generated/src/settempcontrol_screen/: SetTempControlViewBase.cpp
  group Application/generated/images
    ../../generated/images/src/: atdi_logo1.cpp atdi_logo_2.cpp atdi_template480x272.cpp atomLyr01.cpp atomLyr02.cpp atomLyr03.cpp atomLyr04.cpp atomLyr05.cpp atomLyr06.cpp atomLyr07.cpp atomLyr08.cpp atomLyr09.cpp atomLyr10.cpp atomLyr11.cpp atomLyr12.cpp BitmapDatabase.cpp gear_50x50.cpp home_gray50x50.cpp offbtn_50x50.cpp ok-button-th.cpp ok-button_pressed.cpp onbtn_50x50.cpp peare_gul.cpp peare_hvid.cpp Red_Slider_Horizontal_Medium_Indicators_Slider_Round_nob.cpp
  group Application/generated/images/__designer
    ../../generated/images/src/__designer/: Blue_Slider_Horizontal_Medium_Slider_Round_back.cpp Blue_Slider_Horizontal_Medium_Slider_Round_fill.cpp dark_buttons_round_edge_small.cpp dark_buttons_round_edge_small_pressed.cpp
  group Application/generated/texts
    ../../generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group Application/gui/common
    ../../gui/src/common/: FrontendApplication.cpp
  group Application/gui/containers
    ../../gui/src/containers/: AtdiBackground_Btns.cpp
  group Application/gui/main_screen
    ../../gui/src/main_screen/: MainPresenter.cpp MainView.cpp
  group Application/gui/model
    ../../gui/src/model/: Model.cpp
  group Application/gui/screencanbus_screen
    ../../gui/src/screencanbus_screen/: screenCanbusPresenter.cpp screenCanbusView.cpp
  group Application/gui/screenindustrialcontroller_screen
    ../../gui/src/screenindustrialcontroller_screen/: screenIndustrialControllerPresenter.cpp screenIndustrialControllerView.cpp
  group Application/gui/screenmenu_screen
    ../../gui/src/screenmenu_screen/: screenMenuPresenter.cpp screenMenuView.cpp
  group Application/gui/screenmodbus_screen
    ../../gui/src/screenmodbus_screen/: screenModbusPresenter.cpp screenModbusView.cpp
  group Application/gui/screenzone_screen
    ../../gui/src/screenzone_screen/: screenZonePresenter.cpp screenZoneView.cpp
  group Application/gui/settempcontrol_screen
    ../../gui/src/settempcontrol_screen/: SetTempControlPresenter.cpp SetTempControlView.cpp
  group Application/main
    ../: main.cpp
  group Board/STM32F746G-DISCO
    ../bsp/source/: BoardConfiguration.cpp GPIO.cpp
  group Board/STM32F746G-DISCO/BSP
    ../bsp/source/bsp/: STM32F746GTouchController.cpp STM32F7Instrumentation.cpp
  group Board/STM32F746G-DISCO/Vendor
    ../bsp/source/vendor/Components/ft5336/: ft5336.c
    ../bsp/source/vendor/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_lcd.c stm32746g_discovery_qspi.c stm32746g_discovery_sd.c stm32746g_discovery_sdram.c stm32746g_discovery_ts.c
  group MCU
    ../bsp/source/platform/stm32f7xx/: STM32F7DMA.cpp STM32F7HAL.cpp
  group MCU/stm32f7xx
    ../bsp/source/platform/stm32f7xx/IAR/: startup_stm32f746xx.s
    ../bsp/source/platform/stm32f7xx/STM32F7xx_HAL_Driver/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_msp_template.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
    ../bsp/source/platform/stm32f7xx/CMSIS/: system_stm32f7xx.c
  group OS
    ../os/FreeRTOS8.2.0/: OSWrappers.cpp
  group OS/FreeRTOS8.2.0
    ../os/FreeRTOS8.2.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../os/FreeRTOS8.2.0/Source/portable/MemMang/: heap_2.c
    ../os/FreeRTOS8.2.0/Source/portable/IAR/ST_CM7/: port.c portasm.s
