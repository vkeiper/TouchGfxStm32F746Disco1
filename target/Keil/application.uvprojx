# Keil uVision project application.uvprojx, settings and files
target STM32F746G-DISCO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: application +hex
  AfterMake: fromelf --only=ExtFlashSection --bin --output=binary .\Flash\application.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: ST STM32F756xx USE_FREERTOS_8 USE_OS_SYSTICK USE_STM32746G_DISCOVERY USE_BPP=16
  c include: ../../touchgfx/framework/include;../../gui/include;../../platform/os;../../generated/fonts/include;../../generated/images/include;../../generated/texts/include;../../generated/gui_generated/include;../bsp/include;../bsp/include/platform/core/arm/cortex-m/CMSIS;../bsp/include/platform/stm32f7xx;../bsp/include/platform/stm32f7xx/CMSIS;../bsp/include/platform/stm32f7xx/STM32F7xx_HAL_Driver;../bsp/include;../bsp/include/vendor;../bsp/source/vendor/STM32746G-Discovery;../os/FreeRTOS8.2.0/Source/include;../os/FreeRTOS8.2.0/Source/portable/RVDS/ST_CM7;..\TraceRecorder\include;..\TraceRecorder\config;..\TraceRecorder\streamports\Jlink_RTT\include
  asm include: ../os/FreeRTOSV8.2.0/FreeRTOS/Source/include;../os/FreeRTOSV8.2.0/FreeRTOS/Source/portable/RVDS/ST_CM7
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x9000000 size 0x10000000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\Flash_QSPI.sct
  group Startup
    ../: main.cpp
    ../bsp/source/platform/stm32f7xx/CMSIS/: system_stm32f7xx.c
    ../bsp/source/platform/stm32f7xx/Keil/: startup_stm32f746xx.s
    ../bsp/source/: btntask.c ledtask.c
  group TouchGFXHAL
    ../bsp/source/platform/stm32f7xx/: STM32F7DMA.cpp STM32F7HAL.cpp
    ../bsp/source/: BoardConfiguration.cpp GPIO.cpp
    ../bsp/source/bsp/: STM32F7Instrumentation.cpp STM32F746GTouchController.cpp
    ../bsp/source/vendor/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_lcd.c stm32746g_discovery_sd.c stm32746g_discovery_sdram.c stm32746g_discovery_ts.c stm32746g_discovery_qspi.c
  group OS
    ../os/FreeRTOS8.2.0/Source/: croutine.c event_groups.c list.c queue.c readme.txt tasks.c timers.c
    ../os/FreeRTOS8.2.0/: OSWrappers.cpp
    ../os/FreeRTOS8.2.0/Source/portable/RVDS/ST_CM7/: port.c
    ../os/FreeRTOS8.2.0/Source/portable/MemMang/: heap_2.c
  group HAL
    ../bsp/source/vendor/Components/ft5336/: ft5336.c
    ../bsp/source/platform/stm32f7xx/STM32F7xx_HAL_Driver/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_msp_template.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
  group Lib
    ../../touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
  group gui
    ../../gui/src/containers/: atdibackground_btns.cpp
    ../../gui/src/common/: frontendapplication.cpp
    ../../gui/src/main_screen/: mainpresenter.cpp mainview.cpp
    ../../gui/src/model/: model.cpp
    ../../gui/src/screencanbus_screen/: screencanbuspresenter.cpp screencanbusview.cpp
    ../../gui/src/screenindustrialcontroller_screen/: screenindustrialcontrollerpresenter.cpp screenindustrialcontrollerview.cpp
    ../../gui/src/screenmenu_screen/: screenmenupresenter.cpp screenmenuview.cpp
    ../../gui/src/screenmodbus_screen/: screenmodbuspresenter.cpp screenmodbusview.cpp
    ../../gui/src/screenzone_screen/: screenzonepresenter.cpp screenzoneview.cpp
    ../../gui/src/settempcontrol_screen/: settempcontrolpresenter.cpp settempcontrolview.cpp
  group generated
    ../../generated/fonts/src/: applicationfontprovider.cpp font_verdana_20_4bpp.cpp font_verdana_45_4bpp.cpp font_verdanab_75_4bpp.cpp font_verdanaz_30_4bpp.cpp fontgetters.cpp kerning_verdana_20_4bpp.cpp kerning_verdana_45_4bpp.cpp kerning_verdanab_75_4bpp.cpp kerning_verdanaz_30_4bpp.cpp table_verdana_20_4bpp.cpp table_verdana_45_4bpp.cpp table_verdanab_75_4bpp.cpp table_verdanaz_30_4bpp.cpp
    ../../generated/images/src/: atdi_logo1.cpp atdi_logo_2.cpp atdi_template480x272.cpp atomlyr01.cpp atomlyr02.cpp atomlyr03.cpp atomlyr04.cpp atomlyr05.cpp atomlyr06.cpp atomlyr07.cpp atomlyr08.cpp atomlyr09.cpp atomlyr10.cpp atomlyr11.cpp atomlyr12.cpp bitmapdatabase.cpp gear_50x50.cpp home_gray50x50.cpp offbtn_50x50.cpp ok-button-th.cpp ok-button_pressed.cpp onbtn_50x50.cpp peare_gul.cpp peare_hvid.cpp red_slider_horizontal_medium_indicators_slider_round_nob.cpp
    ../../generated/gui_generated/src/containers/: atdibackground_btnsbase.cpp
    ../../generated/images/src/__designer/: blue_slider_horizontal_medium_slider_round_back.cpp blue_slider_horizontal_medium_slider_round_fill.cpp dark_buttons_round_edge_small.cpp dark_buttons_round_edge_small_pressed.cpp
    ../../generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../../generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../../generated/gui_generated/src/main_screen/: mainviewbase.cpp
    ../../generated/gui_generated/src/screencanbus_screen/: screencanbusviewbase.cpp
    ../../generated/gui_generated/src/screenindustrialcontroller_screen/: screenindustrialcontrollerviewbase.cpp
    ../../generated/gui_generated/src/screenmenu_screen/: screenmenuviewbase.cpp
    ../../generated/gui_generated/src/screenmodbus_screen/: screenmodbusviewbase.cpp
    ../../generated/gui_generated/src/screenzone_screen/: screenzoneviewbase.cpp
    ../../generated/gui_generated/src/settempcontrol_screen/: settempcontrolviewbase.cpp
  group Trace
    ../TraceRecorder/: trcKernelPort.c trcStreamingRecorder.c
    ../TraceRecorder/streamports/Jlink_RTT/: SEGGER_RTT.c trcStreamingPort.c
